FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://sixlinux.cfg"
